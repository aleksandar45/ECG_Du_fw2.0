# Keil uVision project iCardiologist.uvprojx, settings and files
target ECG_Du_v1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iCardiologist +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L452xx,USE_HAL_DRIVER,
  c include: .\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c
  group Doc
    ./: ReadMe.txt
  group Drivers/CMSIS
    ./Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l462xx.s
  group Example/User
    ./Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c BLE_RN4871.c ECG_ADS1294.c resources.c BATT.c
  group mDrivers
    ./Src/: mTimer.c mPWR.c mUART.c mSPI.c mADC.c mFLASHInt.c
software components: CMSIS:CORE 5.1.1
